// ============================================================
// DisplayManager.cpp — Local ST7789 TFT UI
// Uses TFT_eSPI library (configured via build flags in platformio.ini)
// ============================================================
#include "DisplayManager.h"
#include "../radio/RadioController.h"
#include "../radio/BandConfig.h"
#include "../power/PowerManager.h"
#include "../input/EncoderHandler.h"
#include <TFT_eSPI.h>
#include <WiFi.h>
#include <esp_log.h>
#include <time.h>

static const char* TAG = "Display";
extern RadioController radioController;

// TFT instance (configured via TFT_eSPI build flags)
static TFT_eSPI tft = TFT_eSPI();
static TFT_eSprite spr = TFT_eSprite(&tft);  // Sprite for flicker-free updates

// ============================================================
// Color palette (dark theme)
// ============================================================
#define C_BG        TFT_BLACK
#define C_FREQ      0x07FF   // Cyan
#define C_MODE      0xFFE0   // Yellow
#define C_BAND      0xFB00   // Orange
#define C_RSSI_BAR  0x07E0   // Green
#define C_SNR_BAR   0x001F   // Blue
#define C_RDS       0xF81F   // Magenta
#define C_LABEL     0x8410   // Dark grey
#define C_VALUE     0xFFFF   // White
#define C_STEREO    0x07E0   // Green when stereo
#define C_MONO      0x8410   // Grey when mono
#define C_BAT_OK    0x07E0
#define C_BAT_LOW   0xF800   // Red

// Screen layout constants (320×170 landscape via TFT_eSPI rotation)
#define SCR_W       320
#define SCR_H       170

void DisplayManager::begin() {
    tft.init();
    tft.setRotation(1);    // 1 = landscape, USB connector on right
    tft.fillScreen(C_BG);
    _backlightLevel  = 128;
    _lastActivityMs  = millis();
    analogWrite(TFT_BL, _backlightLevel);

    // Create full-screen sprite for double-buffered rendering
    spr.createSprite(SCR_W, SCR_H);
    spr.setColorDepth(16);

    // Splash screen
    spr.fillSprite(C_BG);
    spr.setTextColor(C_FREQ, C_BG);
    spr.setTextSize(2);
    spr.setCursor(40, 60);
    spr.print("T-Embed SI4732");
    spr.setTextSize(1);
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(80, 90);
    spr.print("Initialising...");
    spr.pushSprite(0, 0);

    ESP_LOGI(TAG, "Display ready: %dx%d", SCR_W, SCR_H);
}

void DisplayManager::wakeDisplay() {
    _lastActivityMs = millis();
    if (_backlightLevel != 128) {
        _backlightLevel = 128;
        analogWrite(TFT_BL, 128);
    }
}

void DisplayManager::setSleepCountdown(int secsRemaining) {
    _sleepCountdown = secsRemaining;
}

// ============================================================
// drawSleepScreen — final frame before deep sleep
// Renders "Going to sleep" message, pauses ~600 ms, blanks backlight.
// Call immediately before esp_deep_sleep_start().
// ============================================================
void DisplayManager::drawSleepScreen() {
    spr.fillSprite(C_BG);
    spr.setFreeFont(nullptr);
    spr.setTextSize(2);
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(55, 65);
    spr.print("Going to sleep");
    spr.setTextSize(1);
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(60, 95);
    spr.print("Press button to wake");
    spr.pushSprite(0, 0);
    delay(600);
    analogWrite(TFT_BL, 0);
}

void DisplayManager::update() {
    radioController.lockStatus();
    RadioStatus s = radioController.getStatus();
    radioController.unlockStatus();

    // Auto-dim/sleep backlight on idle
    uint32_t idle = millis() - _lastActivityMs;
    if (idle > SLEEP_TIMEOUT_MS && _backlightLevel != 0) {
        _backlightLevel = 0;
        analogWrite(TFT_BL, 0);
    } else if (idle > DIM_TIMEOUT_MS && _backlightLevel == 128) {
        _backlightLevel = 64;
        analogWrite(TFT_BL, 64);   // dim to ~25% (level 20 appeared black)
    }

    spr.fillSprite(C_BG);

    _drawFrequency(s);
    _drawModeAndBand(s);
    _drawSignalMeter(s);
    _drawRDS(s);
    _drawBattery(s);
    _drawSSBInfo(s);
    _drawWifiStatus();
    _drawClock();
    _drawEncoderTarget();

    if (_sleepCountdown >= 1) {
        _drawSleepCountdownOverlay();
    }

    spr.pushSprite(0, 0);
}

// ============================================================
// Frequency display — large font, centre of screen
// ============================================================
void DisplayManager::_drawFrequency(const RadioStatus& s) {
    char freqStr[20];

    if (s.mode == DemodMode::FM) {
        // FM: frequencyKHz is in 100kHz units, displayFreqHz in 10kHz units
        // e.g. frequencyKHz=10390 → 103.90 MHz
        float mhz = s.frequencyKHz / 100.0f;
        snprintf(freqStr, sizeof(freqStr), "%.1f MHz", mhz);
    } else if (s.mode == DemodMode::LSB ||
               s.mode == DemodMode::USB ||
               s.mode == DemodMode::CW) {
        // SSB/CW: use displayFreqHz (chip kHz * 1000 + BFO Hz)
        // Show with 2 decimal places in kHz (e.g. 14074.20 kHz → 14.07420 MHz)
        float mhz = s.displayFreqHz / 1000000.0f;
        snprintf(freqStr, sizeof(freqStr), "%.6f", mhz);
        // Trim trailing zeros after decimal point
        char* dot = strchr(freqStr, '.');
        if (dot) {
            char* end = freqStr + strlen(freqStr) - 1;
            while (end > dot + 3 && *end == '0') *end-- = ' ';
        }
        strncat(freqStr, " MHz", sizeof(freqStr) - strlen(freqStr) - 1);
    } else if (s.frequencyKHz >= 1000) {
        // SW/AM: kHz → MHz with 3 decimals
        float mhz = s.frequencyKHz / 1000.0f;
        snprintf(freqStr, sizeof(freqStr), "%.3f MHz", mhz);
    } else {
        // LW/MW: show as kHz
        snprintf(freqStr, sizeof(freqStr), "%lu kHz", (unsigned long)s.frequencyKHz);
    }

    spr.setTextColor(C_FREQ, C_BG);
    spr.setFreeFont(&FreeSansBold18pt7b);
    spr.setCursor(10, 45);
    spr.print(freqStr);

    // Stereo/mono indicator for FM
    if (s.mode == DemodMode::FM) {
        spr.setTextColor(s.stereo ? C_STEREO : C_MONO, C_BG);
        spr.setTextSize(1);
        spr.setCursor(270, 30);
        spr.print(s.stereo ? "ST" : "MN");
    }
}

// ============================================================
// Mode and band labels
// ============================================================
void DisplayManager::_drawModeAndBand(const RadioStatus& s) {
    spr.setFreeFont(nullptr);
    spr.setTextSize(1);

    // Mode badge
    spr.fillRoundRect(10, 55, 44, 16, 4, C_MODE);
    spr.setTextColor(C_BG, C_MODE);
    spr.setCursor(14, 58);
    spr.print(demodModeStr(s.mode));

    // Band name
    spr.setTextColor(C_BAND, C_BG);
    spr.setCursor(62, 58);
    spr.print(BAND_TABLE[s.bandIndex].name);
}

// ============================================================
// Signal meter — RSSI and SNR bars
// ============================================================
void DisplayManager::_drawSignalMeter(const RadioStatus& s) {
    const int barX   = 10;
    const int barY   = 80;
    const int barW   = 240;
    const int barH   = 10;
    const int maxRSSI = 80;  // typical max dBuV

    // RSSI bar
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(barX, barY - 2);
    spr.print("RSSI");
    int rssiW = map(constrain(s.rssi, 0, maxRSSI), 0, maxRSSI, 0, barW);
    spr.drawRect(barX + 28, barY - 2, barW, barH, C_LABEL);
    spr.fillRect(barX + 28, barY - 2, rssiW, barH, C_RSSI_BAR);
    // Peak-hold tick mark (white vertical line)
    if (s.rssiPeak > 0 && s.rssiPeak >= s.rssi) {
        int peakX = barX + 28 + map(constrain(s.rssiPeak, 0, maxRSSI), 0, maxRSSI, 0, barW - 1);
        spr.drawFastVLine(peakX, barY - 2, barH, C_VALUE);
    }

    // S-meter label: S9 = 34 dBμV, each unit = 6 dB
    char buf[12];
    int sUnits = constrain(9 + ((int)s.rssi - 34) / 6, 0, 9);
    int above  = (int)s.rssi - 34;
    if (above > 0)
        snprintf(buf, sizeof(buf), "S9+%d", above);
    else
        snprintf(buf, sizeof(buf), "S%d", sUnits);
    spr.setTextColor(C_VALUE, C_BG);
    spr.setCursor(barX + 28 + barW + 4, barY - 2);
    spr.print(buf);

    // SNR bar
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(barX, barY + 14);
    spr.print("SNR ");
    int snrW = map(constrain(s.snr, 0, 50), 0, 50, 0, barW);
    spr.drawRect(barX + 28, barY + 14, barW, barH, C_LABEL);
    spr.fillRect(barX + 28, barY + 14, snrW, barH, C_SNR_BAR);
    snprintf(buf, sizeof(buf), "%3d", s.snr);
    spr.setTextColor(C_VALUE, C_BG);
    spr.setCursor(barX + 28 + barW + 4, barY + 14);
    spr.print(buf);
}

// ============================================================
// RDS station name / program info
// PS  (rdsStationName): up to 8 chars — static, always fits
// RT  (rdsProgramInfo): up to 64 chars — scrolled when longer
//     than the display window (~40 chars at font size 1).
//     Scroll advances one character per SCROLL_FRAME_INTERVAL
//     display updates (~10 fps), pauses at the start for
//     SCROLL_PAUSE_FRAMES before looping.
// ============================================================
void DisplayManager::_drawRDS(const RadioStatus& s) {
    if (s.mode != DemodMode::FM) return;

    spr.setTextColor(C_RDS, C_BG);
    spr.setTextSize(1);

    if (s.rdsStationName[0]) {
        spr.setCursor(10, 108);
        spr.print(s.rdsStationName);
    }

    if (!s.rdsProgramInfo[0]) return;

    static constexpr int  DISPLAY_CHARS         = 40;  // chars that fit on one line
    static constexpr int  SCROLL_FRAME_INTERVAL = 5;   // display frames per scroll step
    static constexpr int  SCROLL_PAUSE_FRAMES   = 20;  // pause at start before looping
    static int  _scrollOffset = 0;
    static int  _frameCount   = 0;
    static char _lastRT[65]   = {};

    // Reset scroll when RT content changes (new station or new song)
    if (strncmp(_lastRT, s.rdsProgramInfo, 64) != 0) {
        strncpy(_lastRT, s.rdsProgramInfo, 64);
        _lastRT[64] = '\0';
        _scrollOffset = 0;
        _frameCount   = 0;
    }

    int rtLen = (int)strlen(s.rdsProgramInfo);

    // Advance scroll position every SCROLL_FRAME_INTERVAL frames,
    // but only when the text is longer than the display window.
    if (rtLen > DISPLAY_CHARS) {
        if (++_frameCount >= SCROLL_FRAME_INTERVAL + (_scrollOffset == 0 ? SCROLL_PAUSE_FRAMES : 0)) {
            _frameCount = 0;
            _scrollOffset++;
            if (_scrollOffset > rtLen) _scrollOffset = 0;  // loop back
        }
    } else {
        _scrollOffset = 0;
    }

    // Extract the visible window starting at _scrollOffset
    char window[DISPLAY_CHARS + 1];
    int  startIdx = _scrollOffset % (rtLen + 1);
    int  avail    = rtLen - startIdx;
    int  take     = (avail < DISPLAY_CHARS) ? avail : DISPLAY_CHARS;
    strncpy(window, s.rdsProgramInfo + startIdx, take);
    window[take] = '\0';

    spr.setCursor(10, 120);
    spr.print(window);
}

// ============================================================
// Battery indicator (top-right)
// ============================================================
void DisplayManager::_drawBattery(const RadioStatus& s) {
    // Use BQ27220 fuel gauge percentage if available (-1 means unavailable).
    // Fall back to voltage-derived estimate only if gauge absent.
    int pct;
    if (s.batteryPercent >= 0) {
        pct = s.batteryPercent;
    } else {
        // Fallback: LiPo discharge curve estimate
        pct = PowerManager::voltageToPercent(s.batteryVolts);
    }

    char buf[12];
    if (s.isCharging) {
        // Show charging indicator
        snprintf(buf, sizeof(buf), "%d%%+", pct);
    } else {
        snprintf(buf, sizeof(buf), "%d%%", pct);
    }

    // Colour: green >20%, red <=20%, yellow when charging
    uint16_t color;
    if (s.isCharging)    color = 0xFFE0;   // yellow
    else if (pct > 20)   color = C_BAT_OK; // green
    else                 color = C_BAT_LOW; // red

    spr.setTextColor(color, C_BG);
    spr.setTextSize(1);
    spr.setCursor(285, 5);
    spr.print(buf);
}

// ============================================================
// SSB BFO display (only in SSB/CW mode)
// ============================================================
void DisplayManager::_drawSSBInfo(const RadioStatus& s) {
    if (s.mode != DemodMode::LSB && s.mode != DemodMode::USB && s.mode != DemodMode::CW) return;
    char buf[20];
    snprintf(buf, sizeof(buf), "BFO:%+d Hz", s.bfoHz);
    spr.setTextColor(C_VALUE, C_BG);
    spr.setTextSize(1);
    spr.setCursor(10, 140);
    spr.print(buf);
}

// ============================================================
// Encoder target tab bar — bottom of screen
// Shows FREQ | VOL | BFO | BAND, active tab highlighted
// ============================================================
void DisplayManager::_drawEncoderTarget() {
    static const char* labels[] = { "FREQ", "VOL", "BFO", "BAND" };
    const int n       = 4;
    const int tabW    = 72;
    const int tabH    = 16;
    const int gap     = 8;
    const int startX  = (SCR_W - (n * tabW + (n - 1) * gap)) / 2;
    const int y       = SCR_H - tabH - 2;
    const int active  = encoderHandler.getTargetIndex();

    spr.setFreeFont(nullptr);
    spr.setTextSize(1);

    for (int i = 0; i < n; i++) {
        int x = startX + i * (tabW + gap);
        if (i == active) {
            spr.fillRoundRect(x, y, tabW, tabH, 3, C_MODE);
            spr.setTextColor(C_BG, C_MODE);
        } else {
            spr.drawRoundRect(x, y, tabW, tabH, 3, C_LABEL);
            spr.setTextColor(C_LABEL, C_BG);
        }
        // Centre the label text inside the tab
        int textX = x + (tabW - strlen(labels[i]) * 6) / 2;
        spr.setCursor(textX, y + 4);
        spr.print(labels[i]);
    }
}

// ============================================================
// _drawClock — UTC time at top-left, shown only after NTP sync
// Epoch < 1700000000 (Nov 2023) means clock not yet set.
// ============================================================
void DisplayManager::_drawClock() {
    time_t now = time(nullptr);
    if (now < 1700000000L) return;  // NTP not synced yet
    struct tm* t = gmtime(&now);
    char buf[10];
    snprintf(buf, sizeof(buf), "%02d:%02d:%02d", t->tm_hour, t->tm_min, t->tm_sec);
    spr.setFreeFont(nullptr);
    spr.setTextSize(1);
    spr.setTextColor(C_LABEL, C_BG);
    spr.setCursor(10, 5);
    spr.print(buf);
}

// ============================================================
// _drawWifiStatus — SSID + IP (STA) or AP fallback, at y=130
// ============================================================
void DisplayManager::_drawWifiStatus() {
    spr.setFreeFont(nullptr);
    spr.setTextSize(1);

    char buf[48];
    if (WiFi.status() == WL_CONNECTED) {
        String ssid = WiFi.SSID();
        if (ssid.length() > 12) ssid = ssid.substring(0, 12);
        snprintf(buf, sizeof(buf), "%s  %s", ssid.c_str(),
                 WiFi.localIP().toString().c_str());
        spr.setTextColor(C_VALUE, C_BG);
    } else {
        snprintf(buf, sizeof(buf), "AP  192.168.4.1");
        spr.setTextColor(C_LABEL, C_BG);
    }
    spr.setCursor(10, 130);
    spr.print(buf);
}

// ============================================================
// _drawSleepCountdownOverlay — shown while button is held for sleep
// Dark rounded box centre-screen; large countdown digit; hint text.
// ============================================================
void DisplayManager::_drawSleepCountdownOverlay() {
    const int boxW = 160, boxH = 80;
    const int boxX = (SCR_W - boxW) / 2;
    const int boxY = (SCR_H - boxH) / 2;

    spr.fillRoundRect(boxX, boxY, boxW, boxH, 8, TFT_NAVY);
    spr.drawRoundRect(boxX, boxY, boxW, boxH, 8, C_LABEL);

    // Large countdown digit
    char buf[4];
    snprintf(buf, sizeof(buf), "%d", _sleepCountdown);
    spr.setFreeFont(&FreeSansBold18pt7b);
    spr.setTextColor(C_FREQ, TFT_NAVY);
    spr.setCursor(boxX + (boxW - (int16_t)spr.textWidth(buf)) / 2, boxY + 48);
    spr.print(buf);

    // Hint text below the digit
    spr.setFreeFont(nullptr);
    spr.setTextSize(1);
    spr.setTextColor(C_LABEL, TFT_NAVY);
    spr.setCursor(boxX + 18, boxY + 62);
    spr.print("Hold to sleep / release");
}

DisplayManager displayManager;
